## zephyr/Kconfig
```kconfig
menuconfig MINITELNET
	bool "minitelnet Telnet protocol library"
	default n
	help
	  Minimal allocation-free Telnet protocol implementation.
```
